Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 3c9c1052-0aff-42b0-a390-62310f3d93d0, NumberOfSaves: 27]
File name: NB-WROORU 825x75 D=250.ifc
Time: 2024-12-02T10:58:12+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_plenum_for_return_wall_grill_wro_LT_Solid_Air:WROO, NLRS_57_DUA_UN_plenum_for_return_wall_grill_wro_LT_Solid_Air:WROO:1610001
In: Default
Type - Material: SACS_Label, NLRS_57_sendzimir verzinkt_gen_sacs
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_plenum_for_return_wall_grill_wro_LT_Solid_Air
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Assembly Code: 57.00; Description: WRO, plenum for wall grill; Manufacturer: Solid Air Climate Solutions; Model: WRO, plenum for wall grill; NLRS_C_content_creator: J.Feeke; NLRS_C_content_datum_gewijzigd: 02-12-2024; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.21.01; NLRS_C_description: WRO, plenum for wall grill; Type Name: WROO; URL: https://solid-air.nl/producten/wto-wro/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: WROO; sets with these values: 2
Other - Family: NLRS_57_DUA_UN_plenum_for_return_wall_grill_wro_LT_Solid_Air; Family and Type: NLRS_57_DUA_UN_plenum_for_return_wall_grill_wro_LT_Solid_Air: WROO; Type: WROO; Type Id: 1609954
Model Properties - Connection side (0-2): 1; Plenum type (0-1): 0; SACS_Option_1: Right; SACS_Option_2: Not insulated
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.887009 m2; NLRS_C_lengte: 425 mm; NLRS_M_c01_breedte: 825 mm; NLRS_M_c01_hoogte: 75 mm; NLRS_M_c02_diameter: 250 mm; SACS_Duct_Height: 75 mm; SACS_Duct_Width: 825 mm; Size: 825x75-250ø-250ø-250ø; Volume: 0.0871749 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 238; NLRS_C_model: WROORU 825x75 D=250; SACS_Article_Code: NB
Mechanical - System Classification: Return Air
Mechanical - Flow - NLRS_M_c01_debiet: 0 dm3/s
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 825 mmx75 mm-250 mmø-250 mmø-250 mmø
Lining - Free Size: 825 mmx75 mm-250 mmø-250 mmø-250 mmø; Lining Thickness: 0 mm

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
InPort_1610001_1 | SINK
OutPort_1610001_2 | SOURCE
OutPort_1610001_3 | SOURCE
OutPort_1610001_4 | SOURCE
